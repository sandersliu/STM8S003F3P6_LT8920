# IAR project demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\user; ..\user\APP; ..\user\SYSTEM; ..\user\HARDWARE
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLIB
    ../FWlib/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group USER/APP
    ../user/APP/: includes.h main.c
  group USER/HARDWARE
    ../user/HARDWARE/: flash_eeprom.c key.c led.c lt8920.c spi.c uart.c
  group USER/SYSTEM
    ../user/SYSTEM/: delay.c stm8s_it.c sys.h sysclock.c
